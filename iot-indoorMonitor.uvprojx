# Keil uVision project iot-indoorMonitor.uvprojx, settings and files
target WIFI-ESP8266 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iot-indoorMonitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\SYSTEM;..\..\STM32F10x_FWLib\inc;..\..\USER;..\..\SYSTEM\sys;..\..\HARDWARE\24CXX;..\..\HARDWARE\ADC;..\..\HARDWARE\ALARM;..\..\HARDWARE\FLASH;..\..\HARDWARE\IIC;..\..\HARDWARE\KEY;..\..\HARDWARE\LCD;..\..\HARDWARE\LED;..\..\HARDWARE\OLED;..\..\HARDWARE\SD;..\..\HARDWARE\SENSOR\CH2O;..\..\HARDWARE\SENSOR\DHT11;..\..\HARDWARE\SENSOR\MQ2;..\..\HARDWARE\SENSOR\PM2.5;..\..\HARDWARE\SPI;..\..\HARDWARE\TIMER;..\..\HARDWARE\TOUCH;..\..\HARDWARE\USART;..\..\SYSTEM\delay;..\..\UCOSII\CONFIG;..\..\UCOSII\CORE;..\..\UCOSII\PORT;..\..\MALLOC;..\..\TEXT;..\..\FATFS\exfuns;..\..\FATFS\src;..\..\USMART;..\..\ATK-ESP8266;..\..\CJSON
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../SYSTEM/: startup_stm32f10x_hd.s
  group System
    ../../SYSTEM/: core_cm3.c system_stm32f10x.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
  group Fwlib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cjson
    ../../CJSON/: cJSON.c
  group Malloc
    ../../MALLOC/: malloc.c
  group Usmart
    ../../USMART/: usmart.c usmart_config.c usmart_str.c
  group Fatfs
    ../../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../../FATFS/src/: diskio.c ff.c
  group Text
    ../../TEXT/: fontupd.c text.c
  group Esp8266
    ../../ATK-ESP8266/: common.c
  group User
    ../../USER/: main.c Process.c stm32f10x_it.c usart.c
  group Hardware
    ../../HARDWARE/24CXX/: 24cxx.c
    ../../HARDWARE/ADC/: adc_1.c
    ../../HARDWARE/ALARM/: alarm.c
    ../../HARDWARE/FLASH/: flash.c
    ../../HARDWARE/IIC/: myiic.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/LCD/: lcd.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/OLED/: oled.c
    ../../HARDWARE/SD/: MMC_SD.C
    ../../HARDWARE/SENSOR/CH2O/: CH2O_Sensor.c
    ../../HARDWARE/SENSOR/DHT11/: DHT11_Sensor.c
    ../../HARDWARE/SENSOR/MQ2/: MQ2_Sensor.c
    ../../HARDWARE/SENSOR/PM2.5/: PM25_Sensor.c
    ../../HARDWARE/SPI/: spi.c
    ../../HARDWARE/TIMER/: timer_3.c timer_1.c timer_6.c
    ../../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../../HARDWARE/USART/: usart_2.c usart_3.c usart_5.c
  group Ucosii-core
    ../../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ucosii-port
    ../../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group Ucosii-config
    ../../UCOSII/CONFIG/: includes.h os_cfg.h
  group Readme
    ../../README/: README.TXT
